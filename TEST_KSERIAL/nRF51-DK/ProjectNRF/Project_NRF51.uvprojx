# Keil uVision project Project_NRF51.uvprojx, settings and files
target NRF51422 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NRF51422 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __CC_ARM, NRF51, ARM_MATH_CM0
  c include: ..\;..\Libraries\CMSIS;..\Libraries\nRF_Drivers\hal;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Libraries/CMSIS/: arm_startup_nrf51.s system_nrf51.c
  group Library
    ../Libraries/nRF_Drivers/hal/: nrf_delay.c
    ../Program/: nrf51_conf.h
  group Driver
    ../Program/drivers/: nrf51_clock.c nrf51_delay.c nrf51_uart.c
  group Program
    ../Program/: experiment_nrf51.c experiment_nrf51_it.c
  group Module
    ../Program/modules/: module_serial.c
  group Algorithm
    ../Program/algorithms/: algorithm_string.c
  group math
    ../Libraries/CMSIS/DSP_Lib/: arm_common_tables.c arm_cos_f32.c arm_sin_f32.c
